#
# CIP Core, generic profile
#
# Copyright (c) Texas Instruments Incorporated, 2026
#
# SPDX-License-Identifier: MIT

require linux-ti-cip-release.inc

SRC_URI[sha256sum] = "539834322739714dc0eef9951f8241681728507356b5fed00a0fb2b8a4a33c2b"
