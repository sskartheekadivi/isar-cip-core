#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2025
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "d85bb43cc091d7cd1b860dceeefad4345d5a9bd39d81c1abb24fd962e21d537f"
