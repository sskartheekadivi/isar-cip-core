#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2026
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "c29d46ea7b96b4d0f3ee8d39d73067b977747ec46331a9f8e47a1db272dde9e5"
