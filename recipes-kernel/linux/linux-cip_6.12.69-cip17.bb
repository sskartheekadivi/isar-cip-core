#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2025
#
# SPDX-License-Identifier: MIT

require linux-cip-release.inc

SRC_URI[sha256sum] = "5185fc3b792317497c8eaf0796ae21bf6b6973655d9ad3c2f26feeb1f661b492"
