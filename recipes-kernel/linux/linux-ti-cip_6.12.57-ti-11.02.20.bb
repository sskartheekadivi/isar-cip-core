#
# CIP Core, generic profile
#
# Copyright (c) Texas Instruments Incorporated, 2026
#
# Authors:
#  Sai Sree Kartheek Adivi <s-adivi@ti.com>
#
# SPDX-License-Identifier: MIT
#

require linux-ti-cip-release.inc

SRC_URI[sha256sum] = "89375aaa2c49f3663ff8f66e8036f822987a7c1e8d387decbf5d3e2e39c11287"
