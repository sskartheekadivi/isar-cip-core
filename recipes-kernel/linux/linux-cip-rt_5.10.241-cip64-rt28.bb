#
# CIP Core, generic profile
#
# Copyright (c) Siemens AG, 2021-2025
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#
# SPDX-License-Identifier: MIT
#

require linux-cip-release.inc

SRC_URI[sha256sum] = "681e2ed1c9407c6050c0b60432050c09cb3257f654368fe3d48880945fddd1c3"
